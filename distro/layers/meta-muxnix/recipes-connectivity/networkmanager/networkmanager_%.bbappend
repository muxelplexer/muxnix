PACKAGECONFIG:append = "nmtui modemmanager"
