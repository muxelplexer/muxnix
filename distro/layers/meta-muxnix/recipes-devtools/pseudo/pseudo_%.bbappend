SRCREV = "43cbd8fb4914328094ccdb4bb827d74b1bac2046"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-update-openat2-signature-for-fcntl.patch"

