FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:luckfox-omni3576 = "luckfox-omni3576"
