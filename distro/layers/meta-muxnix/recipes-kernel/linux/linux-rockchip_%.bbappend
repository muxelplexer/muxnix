DEPENDS:append = " perl"
