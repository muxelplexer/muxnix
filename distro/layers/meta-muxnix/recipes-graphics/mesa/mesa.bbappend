PACKAGECONFIG:append:rk3576 = " gallium vulkan wayland panfrost"
GALLIUMDRIVERS:rk3576:append = "panfrost"
VULKANDRIVERS:rk3576:append = "panfrost"
