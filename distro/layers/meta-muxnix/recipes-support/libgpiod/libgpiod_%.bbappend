PACKAGECONFIG = "gpioset-interactive"
PTEST_ENABLED = "0"
