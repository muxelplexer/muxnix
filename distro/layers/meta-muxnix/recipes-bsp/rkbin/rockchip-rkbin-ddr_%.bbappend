FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
RKBIN_DDR_RECONFIGURE = "1"
