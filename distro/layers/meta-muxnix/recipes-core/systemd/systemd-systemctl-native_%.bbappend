FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-do-not-error-on-discarded-qualifiers.patch"

